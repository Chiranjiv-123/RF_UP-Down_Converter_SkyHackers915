options:
  parameters:
    author: Ishan Moondra
    generate_options: qt_gui
    id: HackRF_One_Spectrum
    output_language: python
    title: Spectrum Analyzer using HackRF One
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 192e3
    step: '1000'
    stop: 8e6
    value: 1e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1e6
    step: 500e3
    stop: 6e9
    value: 93.51e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 102.1e6
    fftsize: '1024'
    name: '"Spectrum Analyzer"'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: tuning
    samp_rate: samp_rate
    type: fc32
    vga: rf_gain
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
