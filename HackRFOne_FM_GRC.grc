options:
  parameters:
    generate_options: qt_gui
    id: HackRF_One_FM
    output_language: python
    title: HackRF One FM
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 93.5*10e5
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 85e6
    step: 100e3
    stop: 110e6
    value: 93.5e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 93.5*10e5
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200*10e2
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8*10e5
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.4*10e5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480*10e2
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75*10e2
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25*10e2
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '40'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: 93.5e6
    dc_offs_enb0: auto
    gain0: '75'
    iq_imbal_enb0: disabled
    rx_agc0: Disabled
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
